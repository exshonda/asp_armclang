# Keil uVision project asp.uvprojx, settings and files
target asp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: asp
  AfterMake: fromelf --m32combined asp.axf --output=asp.srec
  AfterMake: ../../../cfg/cfg/cfg --pass 3 --kernel asp -I. -I ../../../ -I ../../../include -I ../../../arch -I../..  -I ../../../target/nucleo_f401re_armcc -I ../../../target/nucleo_f401re_gcc/stm32fcube -I ../../../arch/arm_m_armcc/stm32f4xx_stm32cube -I ../../../arch/arm_m_gcc/stm32f4xx_stm32cube -I ../../../arch/arm_m_gcc/stm32f4xx_stm32cube/STM32F4xx_HAL_Driver/Inc -I ../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Device/ST/STM32F4xx/Include -I ../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Include -I ../../../arch/arm_m_armcc/common -I ../../../arch/arm_m_gcc/common -I ../../../arch/armcc -I ../../../target/nucleo_f401re_gcc --rom-image asp.srec --symbol-table asp.syms -T  ../../../target/nucleo_f401re_armcc/target_check.tf --api-table  ../../../kernel/kernel_api.csv --cfg1-def-table  ../../../kernel/kernel_def.csv  --cfg1-def-table  ../../../arch/arm_m_gcc/common/core_def.csv sample1.cfg
  c flags: Optim=4
  c define: STM32F401xE,TOPPERS_CORTEX_M4
  c misc: --littleend --apcs=/interwork --diag_style=gnu --gnu --bss_threshold=0 --thumb
  c include: ; . ;  ../../../ ;  ../../../include ;  ../../../arch ; ../..  ;  ../../../target/nucleo_f401re_armcc ;  ../../../target/nucleo_f401re_gcc/stm32fcube ;  ../../../arch/arm_m_armcc/stm32f4xx_stm32cube ;  ../../../arch/arm_m_gcc/stm32f4xx_stm32cube ;  ../../../arch/arm_m_gcc/stm32f4xx_stm32cube/STM32F4xx_HAL_Driver/Inc ;  ../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Device/ST/STM32F4xx/Include ;  ../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Include ;  ../../../arch/arm_m_armcc/common ;  ../../../arch/arm_m_gcc/common ;  ../../../arch/armcc ;  ../../../target/nucleo_f401re_gcc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: ..\stm32f401re.scat
  link misc: --diag_style=gnu --datacompressor=off  --no_remove --entry=_kernel__start  --symdefs=asp.syms
  group app
    ../../../sample/: sample1.c
  group syssvc
    ../../../syssvc/: banner.c logtask.c serial.c syslog.c
    ../../../library/: log_output.c strerror.c t_perror.c vasyslog.c
    ../../../arch/arm_m_gcc/stm32f4xx_stm32cube/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_gpio.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma.c
    ../../../arch/arm_m_gcc/stm32f4xx_stm32cube/: usart.c
  group kernel
    ./: kernel_cfg.c libkernel.lib
    ../../../arch/arm_m_armcc/common/: start.sx
software components: CMSIS:CORE 5.0.1
