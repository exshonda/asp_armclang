# Keil uVision project cfg1_out.uvprojx, settings and files
target cfg1_out (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cfg1_out
  BeforeMake: ../../../cfg/cfg/cfg --pass 1 --kernel asp -I. -I../../../ -I../../../include -I../../../arch -I../..  -I../../../target/nucleo_f401re_armcc -I../../../target/nucleo_f401re_gcc/stm32fcube -I../../../arch/arm_m_armcc/stm32f4xx_stm32cube -I../../../arch/arm_m_gcc/stm32f4xx_stm32cube -I../../../arch/arm_m_gcc/stm32f4xx_stm32cube/STM32F4xx_HAL_Driver/Inc -I../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Device/ST/STM32F4xx/Include -I../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Include -I../../../arch/arm_m_armcc/common -I../../../arch/arm_m_gcc/common -I../../../arch/armcc -I../../../target/nucleo_f401re_gcc --api-table ../../../kernel/kernel_api.csv --cfg1-def-table ../../../kernel/kernel_def.csv  --cfg1-def-table ../../../arch/arm_m_gcc/common/core_def.csv sample1.cfg
  AfterMake: fromelf --m32combined cfg1_out.axf --output=cfg1_out.srec
  AfterMake: ../../../cfg/cfg/cfg --pass 2 --kernel asp -I. -I../../../ -I../../../include -I../../../arch -I../..  -I../../../target/nucleo_f401re_armcc -I../../../target/nucleo_f401re_gcc/stm32fcube -I../../../arch/arm_m_armcc/stm32f4xx_stm32cube -I../../../arch/arm_m_gcc/stm32f4xx_stm32cube -I../../../arch/arm_m_gcc/stm32f4xx_stm32cube/STM32F4xx_HAL_Driver/Inc -I../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Device/ST/STM32F4xx/Include -I../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Include -I../../../arch/arm_m_armcc/common -I../../../arch/arm_m_gcc/common -I../../../arch/armcc -I../../../target/nucleo_f401re_gcc -T ../../../target/nucleo_f401re_armcc/target.tf --api-table ../../../kernel/kernel_api.csv --cfg1-def-table ../../../kernel/kernel_def.csv  --cfg1-def-table ../../../arch/arm_m_gcc/common/core_def.csv sample1.cfg
  c flags: Optim=4
  c define: STM32F401xE,TOPPERS_CORTEX_M4,ALLFUNC
  c misc: --diag_style=gnu --gnu --bss_threshold=0  --littleend --apcs=/interwork
  c include: .;../../../;../../../include;../../../arch;../.. ;../../../target/nucleo_f401re_armcc;../../../target/nucleo_f401re_gcc/stm32fcube;../../../arch/arm_m_armcc/stm32f4xx_stm32cube;../../../arch/arm_m_gcc/stm32f4xx_stm32cube;../../../arch/arm_m_gcc/stm32f4xx_stm32cube/STM32F4xx_HAL_Driver/Inc;../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Device/ST/STM32F4xx/Include;../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Include;../../../arch/arm_m_armcc/common;../../../arch/arm_m_gcc/common;../../../arch/armcc;../../../target/nucleo_f401re_gcc;../../../kernel
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: ..\..\..\target\nucleo_f401re_armcc\stm32f401re.scat
  link misc: --diag_style=gnu --datacompressor=off --symdefs=cfg1_out.syms --no_remove
  group cfg
    ../../../sample/: sample1.cfg
  group src
    ./: cfg1_out.c
software components: CMSIS:CORE 5.0.1
