# Keil uVision project cfg1_out.uvprojx, settings and files
target cfg1_out (6070000::V6.7::.\ARMCLANG)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: cfg1_out
  BeforeMake: cfg1_out-cfg_pass1.bat
  AfterMake: fromelf --m32combined cfg1_out.axf --output=cfg1_out.srec
  AfterMake: cfg1_out-cfg_pass23.bat
  c flags: Optim=4
  c define: STM32F401xE,TOPPERS_CORTEX_M4,ALLFUNC,__TARGET_ARCH_THUMB=4,TOPPERS_FPU_ENABLE,TOPPERS_FPU_LAZYSTACKING,TOPPERS_FPU_CONTEXT
  c misc: -mlittle-endian
  c include: .;../../../;../../../include;../../../arch;../.. ;../../../target/nucleo_f401re_armclang;../../../target/nucleo_f401re_gcc/stm32fcube;../../../arch/arm_m_armclang/stm32f4xx_stm32cube;../../../arch/arm_m_gcc/stm32f4xx_stm32cube;../../../arch/arm_m_gcc/stm32f4xx_stm32cube/STM32F4xx_HAL_Driver/Inc;../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Device/ST/STM32F4xx/Include;../../../arch/arm_m_gcc/stm32f4xx_stm32cube/CMSIS/Include;../../../arch/arm_m_armclang/common;../../../arch/arm_m_gcc/common;../../../arch/armclang;../../../target/nucleo_f401re_gcc;../../../kernel
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: ..\..\..\target\nucleo_f401re_armcc\stm32f401re.scat
  link misc: --diag_style=gnu --datacompressor=off --symdefs=cfg1_out.syms --no_remove
  group cfg
    ../../../sample/: sample1.cfg
  group src
    ./: cfg1_out.c
software components: CMSIS:CORE 5.0.1
